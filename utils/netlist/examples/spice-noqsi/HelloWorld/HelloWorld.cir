* /usr/local/bin/lepton-netlist -g spice-noqsi -o HelloWorld.cir HelloWorld.sch
* SPICE file generated by spice-noqsi version 20181225
* Send requests or bug reports to jpd@noqsi.com
V1 unnamed_net1 GND dc 0 ac 1
R1 GND out 10k
L1 unnamed_net1 out 1mH
C1 GND out 1nF

.control
ac dec 100 20k 500k
plot db(out)
.endc
