* gnetlist -v -g spice-sdb -o MSA-2643.cir MSA-2643.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 2.10.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from Q1.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 2.10.2007     *
*******************************
.SUBCKT Q1_MSA26F 5 4 6
*vvvvvvvv  Included SPICE model from model/DiodeM1_Q1.mod vvvvvvvv
* This is a diode model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.31.2003 by SDB
.model DIODEM1_Q1   D(IS=1.405e-17 N=1 CJO=2.281e-14
+  VJ=0.729 M=0.44 FC=0.8 TNOM=21)
*^^^^^^^^  End of included SPICE model from model/DiodeM1_Q1.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/DiodeM2_Q1.mod vvvvvvvv
* This is a diode model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.31.2003 by SDB
.model DIODEM2_Q1   D(IS=1e-24 N=1.0029 CJO=2.452e-14
+  VJ=0.8971 M=0.2292 FC=0.8 TNOM=21)
*^^^^^^^^  End of included SPICE model from model/DiodeM2_Q1.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/BJTM1_Q1.mod vvvvvvvv
* This is the BJT model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.31.2003 by SDB
.model BJTM1_Q1   NPN(Bf=1e6 IKF=5.895e-1 ISE=2.838e-19 NE=1.006
+  VAF=44 NF=1 TF=5.37e-12 XTF=20 VTF=0.8 ITF=2.218e-1 PTF=22
+  XTB=0.7 BR=1 IKR=1.1e-2 NC=2 VAR=3.37 NR=1.005 TR=4e-9
+  EG=1.17 IS=4.475e-18 XTI=3 TNOM=21 CJC=2.921e-14
+  VJC=0.6775 MJC=0.3319 XCJC=4.398e-1 FC=0.8 CJE=7.546e-14
+  VJE=0.9907 MJE=0.5063 RB=9.301 IRB=8.18e-5 RBM=0.1 KF=1.643e-23)
*^^^^^^^^  End of included SPICE model from model/BJTM1_Q1.mod ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
Rbx 4 3 3.723
Rcx 1 6 6.386
Ceox 5 3 6.01e-15F
Q1 1 3 2 BJTM1_Q1
Re 5 2 2.158
D2 3 2 DIODEM2_Q1
D1 4 1 DIODEM1_Q1
Ccox 4 1 1.851e-14F
.ends Q1_MSA26F
*******************************
*^^^^^^^^  End of included SPICE model from Q1.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from Q2.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 2.10.2007     *
*******************************
.SUBCKT Q2_MSA26F 5 4 6
*vvvvvvvv  Included SPICE model from model/DiodeM1_Q2.mod vvvvvvvv
* This is a diode model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.30.2003 by SDB
.model DIODEM1_Q2   D(IS=5.62e-17 N=1 CJO=9.676e-14
+  VJ=0.729 M=0.44 FC=0.8 TNOM=21)
*^^^^^^^^  End of included SPICE model from model/DiodeM1_Q2.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/DiodeM2_Q2.mod vvvvvvvv
* This is a diode model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.30.2003 by SDB
.model DIODEM2_Q2   D(IS=1e-24 N=1.0029 CJO=9.023e-14
+  VJ=0.8971 M=2.292e-1 FC=0.8 TNOM=21)
*^^^^^^^^  End of included SPICE model from model/DiodeM2_Q2.mod ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from model/BJTM1_Q2.mod vvvvvvvv
* This is the BJT model used in the Agilent MSA-26 model
* documented in 5980-2496E.pdf.
* Model entered 3.30.2003 by SDB
.model BJTM1_Q2   NPN(Bf=1e6 IKF=5.895e-1 ISE=2.838e-19 NE=1.006
+  VAF=44 NF=1 TF=5.37e-12 XTF=20 VTF=0.8 ITF=8.872e-1 PTF=22
+  XTB=0.7 BR=1 IKR=4.4e-2 NC=2 VAR=3.37 NR=1.005 TR=4e-9
+  EG=1.17 IS=1.79e-17 XTI=3 TNOM=21 CJC=3.717e-14
+  VJC=0.6775 MJC=0.3319 XCJC=4.398e-1 FC=0.8 CJE=3.217e-13
+  VJE=0.9907 MJE=0.5063 RB=2.325 IRB=3.272e-4 RBM=2.5e-2 KF=1.026e-24)
*^^^^^^^^  End of included SPICE model from model/BJTM1_Q2.mod ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
Rbx 4 3 0.463
Q2 1 3 2 BJTM1_Q2
Rcx 1 6 1.716
Ceox 5 3 2.417e-14F
Re 5 2 0.443
D2 3 2 DIODEM2_Q2
D1 4 1 DIODEM1_Q2
Ccox 4 1 6.598e-14F
.ends Q2_MSA26F
*******************************
*^^^^^^^^  End of included SPICE model from Q2.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
L4 0 3 0.386nH
Cout 7 Vout 47pF
Vpwr 6 0 DC 5V
Cpara2 0 7 0.155pF
R4 3 5 5
Cpara1 0 9 0.158pF
R3 3 4 250
L1 9 2 0.833nH
.INCLUDE ./Simulation.cmd
R2 3 2 660
X2 1 4 5 Q2_MSA26F
R1 2 1 560
X1 1 2 4 Q1_MSA26F
Cin Vin 9 47pF
C1 3 5 4pF
L7 1 7 0.407nH
Lc 8 7 22nH
Vin Vsource 0 dc 0 ac 1
L6 3 0 0.313nH
Rc 6 8 50
RL 0 Vout 50
Rth_in Vsource Vin 50
.end
